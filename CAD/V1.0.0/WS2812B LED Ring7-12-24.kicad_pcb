# Repository test-gh-syncer2/Soldered-Smart-LED-WS2812B-Ring7-12-24-hardware-design

## KiCad design CAD/V1.0.0/WS2812B LED Ring7-12-24.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C22, C24, C25, C26, C27, C28, C29, C30, C31, C33, C34, C36, C38, C39, C40, C41, C42, C43: 0603C
FD1, FD2, FD3: FIDUCIAL; FIDUCIAL_23
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16, LED17, LED18, LED19, LED20, LED21, LED22, LED23, LED24, LED25, LED26, LED27, LED28, LED29, LED30, LED31, LED32, LED33, LED34, LED35, LED36, LED37, LED38, LED39, LED40, LED41, LED42, LED43: WS2812B; WS2812B LED
PAD1, PAD2, PAD3, PAD4, PAD5, PAD6, PAD7, PAD8, PAD9, PAD10, PAD11, PAD12, PAD13, PAD14, PAD15, PAD16, PAD17, PAD18, PAD19, PAD20, PAD21, PAD22, PAD23, PAD24: PAD_2x1.5
R1, R2, R3: 100; 0603R

Connections:
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C22.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C33.2, C34.2, C36.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, LED1.3 (GND), LED2.3 (GND), LED3.3 (GND), LED4.3 (GND), LED5.3 (GND), LED6.3 (GND), LED7.3 (GND), LED8.3 (GND), LED9.3 (GND), LED10.3 (GND), LED11.3 (GND), LED12.3 (GND), LED13.3 (GND), LED14.3 (GND), LED15.3 (GND), LED16.3 (GND), LED17.3 (GND), LED18.3 (GND), LED19.3 (GND), LED20.3 (GND), LED21.3 (GND), LED22.3 (GND), LED23.3 (GND), LED24.3 (GND), LED25.3 (GND), LED26.3 (GND), LED27.3 (GND), LED28.3 (GND), LED29.3 (GND), LED30.3 (GND), LED31.3 (GND), LED32.3 (GND), LED33.3 (GND), LED34.3 (GND), LED35.3 (GND), LED36.3 (GND), LED37.3 (GND), LED38.3 (GND), LED39.3 (GND), LED40.3 (GND), LED41.3 (GND), LED42.3 (GND)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
unnamed: LED1.2 (DOUT), LED2.4 (DIN)
unnamed: LED1.4 (DIN), R1.1
unnamed: LED2.2 (DOUT), LED3.4 (DIN)
unnamed: LED3.2 (DOUT), LED4.4 (DIN)
unnamed: LED4.2 (DOUT), LED5.4 (DIN)
unnamed: LED5.2 (DOUT), LED6.4 (DIN)
unnamed: LED6.2 (DOUT), LED7.4 (DIN)
unnamed: LED7.2 (DOUT), PAD5.1, PAD8.1
unnamed: LED8.2 (DOUT), LED9.4 (DIN)
unnamed: LED8.4 (DIN), R2.1
unnamed: LED10.2 (DOUT), LED11.4 (DIN)
unnamed: LED9.2 (DOUT), LED10.4 (DIN)
unnamed: LED11.2 (DOUT), LED12.4 (DIN)
unnamed: LED12.2 (DOUT), LED13.4 (DIN)
unnamed: LED13.2 (DOUT), LED14.4 (DIN)
unnamed: LED14.2 (DOUT), LED16.4 (DIN)
unnamed: LED15.2 (DOUT), LED17.4 (DIN)
unnamed: LED15.4 (DIN), LED18.2 (DOUT)
unnamed: LED16.2 (DOUT), LED18.4 (DIN)
unnamed: LED17.2 (DOUT), LED19.4 (DIN)
unnamed: LED19.2 (DOUT), PAD14.1, PAD15.1
unnamed: LED20.2 (DOUT), LED22.4 (DIN)
unnamed: LED20.4 (DIN), R3.1
unnamed: LED21.2 (DOUT), LED23.4 (DIN)
unnamed: LED21.4 (DIN), LED41.2 (DOUT)
unnamed: LED22.2 (DOUT), LED24.4 (DIN)
unnamed: LED23.2 (DOUT), LED25.4 (DIN)
unnamed: LED24.2 (DOUT), LED26.4 (DIN)
unnamed: LED25.2 (DOUT), LED27.4 (DIN)
unnamed: LED26.2 (DOUT), LED29.4 (DIN)
unnamed: LED27.2 (DOUT), LED30.4 (DIN)
unnamed: LED28.2 (DOUT), LED31.4 (DIN)
unnamed: LED28.4 (DIN), LED42.2 (DOUT)
unnamed: LED29.2 (DOUT), LED32.4 (DIN)
unnamed: LED30.2 (DOUT), LED33.4 (DIN)
unnamed: LED31.2 (DOUT), LED34.4 (DIN)
unnamed: LED32.2 (DOUT), LED35.4 (DIN)
unnamed: LED33.2 (DOUT), LED36.4 (DIN)
unnamed: LED34.2 (DOUT), LED37.4 (DIN)
unnamed: LED35.2 (DOUT), LED38.4 (DIN)
unnamed: LED36.2 (DOUT), LED39.4 (DIN)
unnamed: LED37.2 (DOUT), LED40.4 (DIN)
unnamed: LED38.2 (DOUT), LED41.4 (DIN)
unnamed: LED39.2 (DOUT), LED42.4 (DIN)
unnamed: LED40.2 (DOUT), LED43.4 (DIN)
unnamed: LED43.2 (DOUT), PAD22.1, PAD23.1
unnamed: PAD2.1, PAD7.1, R1.2
unnamed: PAD10.1, PAD11.1, R2.2
unnamed: PAD18.1, PAD19.1, R3.2
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C22.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C33.1, C34.1, C36.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, LED1.1 (VDD), LED2.1 (VDD), LED3.1 (VDD), LED4.1 (VDD), LED5.1 (VDD), LED6.1 (VDD), LED7.1 (VDD), LED8.1 (VDD), LED9.1 (VDD), LED10.1 (VDD), LED11.1 (VDD), LED12.1 (VDD), LED13.1 (VDD), LED14.1 (VDD), LED15.1 (VDD), LED16.1 (VDD), LED17.1 (VDD), LED18.1 (VDD), LED19.1 (VDD), LED20.1 (VDD), LED21.1 (VDD), LED22.1 (VDD), LED23.1 (VDD), LED24.1 (VDD), LED25.1 (VDD), LED26.1 (VDD), LED27.1 (VDD), LED28.1 (VDD), LED29.1 (VDD), LED30.1 (VDD), LED31.1 (VDD), LED32.1 (VDD), LED33.1 (VDD), LED34.1 (VDD), LED35.1 (VDD), LED36.1 (VDD), LED37.1 (VDD), LED38.1 (VDD), LED39.1 (VDD), LED40.1 (VDD), LED41.1 (VDD), LED42.1 (VDD)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

Notes on the sheet:
Ring 12LED
Ring 24LED
Ring 7LED

Board: 2 copper layers, 79.0 x 79.0 mm, 111 parts (7 on the bottom side), 51 nets.

## Commit log

2021-09-23 Syncing to git
2021-09-23 Updating open source files.
